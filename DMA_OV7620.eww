<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\build\dma_demo\DMA_OV7620.ewp</path>
  </project>
  <batchBuild/>
</workspace>


